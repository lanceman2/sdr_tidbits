options:
  parameters:
    description: reads stdin and feeds GNUradio QT GUI Sink Scope
    generate_options: qt_gui
    id: tb_GNURadioScope
    output_language: python
    title: tb_GNURadioScope
  states: {}

blocks:
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '1000000.0'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_descriptor_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
