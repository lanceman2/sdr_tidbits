options:
  parameters:
    description: reads stdin and feeds GNUradio QT GUI Sink Plotter
    generate_options: qt_gui
    id: tb_plotter
    output_language: python
    title: tb_plotter
  states: {}

blocks:
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'True'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    plotfreq: 'False'
    plotwaterfall: 'False'
    type: float
  states: {}

connections:
- [blocks_file_descriptor_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
